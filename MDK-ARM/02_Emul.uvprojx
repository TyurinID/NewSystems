# Keil uVision project 02_Emul.uvprojx, settings and files
target 02_Emul (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 02_Emul
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;..\Inc\UART;..\Src\UART;D:\Distr\st\STM32Cube_FW_F4_V1.13.0\Drivers\STM32F4xx_HAL_Driver\Inc;D:\Distr\st\STM32Cube_FW_F4_V1.13.0\Drivers\STM32F4xx_HAL_Driver\Src;D:\Distr\st\STM32Cube_FW_F4_V1.13.0\Drivers\STM32F4xx_HAL_Driver;D:\Distr\st\STM32Cube_FW_F4_V1.13.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\Distr\st\STM32Cube_FW_F4_V1.13.0\Drivers\CMSIS\Device\ST\STM32F4xx\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    D:/Distr/st/STM32Cube_FW_F4_V1.13.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c
  group Application/UART
    ../Inc/UART/: uart.h
    ../Src/UART/: uart.c uart_dma_HAL_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    D:/Distr/st/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
software components: CMSIS:CORE 4.1.0
